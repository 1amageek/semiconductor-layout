VERSION 5.8 ; UNITS DATABASE MICRONS 1000 ; END UNITS
LAYER metH TYPE ROUTING ; DIRECTION HORIZONTAL ; PITCH 0.2 ; OFFSET 0.1 ; WIDTH 0.1 ; SPACING 0.1 ; END metH
LAYER cutHV TYPE CUT ; WIDTH 0.05 ; SPACING 0.05 ; END cutHV
LAYER metV TYPE ROUTING ; DIRECTION VERTICAL ; PITCH 0.4 ; OFFSET 0.1 ; WIDTH 0.1 ; SPACING 0.1 ; END metV
SITE unit CLASS CORE ; SIZE 0.1 BY 1 ; SYMMETRY X Y R90 ; END unit
VIA hv DEFAULT
  LAYER metH ; RECT -0.1 -0.1 0.1 0.1 ;
  LAYER cutHV ; RECT -0.025 -0.025 0.025 0.025 ;
  LAYER metV ; RECT -0.1 -0.1 0.1 0.1 ; RESISTANCE 0.75 ;
END hv END LIBRARY